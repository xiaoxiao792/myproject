# Keil uVision project stm32f4_project.uvprojx, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_project
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\CMSIS\Include;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group user
    ./user/src/: main.c led.c beep.c key.c systick.c time.c hc_sr.c
software components: CMSIS:CORE 5.0.1
