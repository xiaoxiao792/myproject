# Keil uVision project study.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: study +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\cmsis;.\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/src/: led.c main.c key.c systick.c motor.c usart.c mg200.c spi.c oled.c font.c voice.c rfid.c MPR121.c iic.c
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
